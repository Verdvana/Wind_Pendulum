# Keil uVision project usart_test2.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC-STC12
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: usart_test2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c usart.c timer.c PWM.c 1602.c find_road.c yundong.c ceju.c
